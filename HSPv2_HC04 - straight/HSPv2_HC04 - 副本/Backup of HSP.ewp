# IAR project Backup of HSP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xG GD GD32F470xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F470
  ICCARM.CCIncludePath2: Main; Board; CMSIS; CMSIS\GD\GD32F4xx\Include; GD32F4xx_standard_peripheral\Include; Main; Utilities; App; FatFS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HSP.hex
  ILINK.IlinkOutputFile: HSP.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/GD/GD32F470xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/: 00_MENU.c Ex1_gpio.c Ex2_I2c.c Ex3_tft18.c Ex4_adc.c Ex5_uart.c Ex6_pwm.c Ex7_dci.c Ex8_rtc.c Lab1_hmi.c Lab2_sensor.c Lab3_ccd.c Lab4_motor.c Project1_LineFollower.c
  group Board
    Board/: hsp_adc.c hsp_dci.c hsp_gpio.c hsp_i2c.c hsp_rtc.c hsp_spi.c hsp_timer.c hsp_uart.c
  group CMSIS
    CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    Doc/: hsp_pin_mux.xlsx
  group FatFS
    FatFS/: diskio.c ff.c ffunicode.c
  group GD32F470_Peripherals
    GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Main
    Main/: gd32f4xx_it.c main.c systick.c
  group Startup
    CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
  group Utilities
    Utilities/: GFX_FUNCTIONS.c HSP_CAT9555.c HSP_COMM.c HSP_ENCODER.c HSP_GD25Q64.c HSP_MMA8451.c HSP_MOTOR.c HSP_MT9V034.c HSP_SDCARD.c HSP_TFT18.c HSP_TSL1401.c HSP_WRITE.c
