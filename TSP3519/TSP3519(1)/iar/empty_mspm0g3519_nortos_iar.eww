<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\empty_mspm0g3519_nortos_iar.ewp</path>
    </project>
    <batchBuild />
</workspace>
