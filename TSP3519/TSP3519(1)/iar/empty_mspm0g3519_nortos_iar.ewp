# IAR project empty_mspm0g3519_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0G3519 TexasInstruments MSPM0G3519
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __MSPM0G3519__
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/Core/Include; $MSPM0_SDK_INSTALL_DIR$/source; ..\NUEDC2025; ..\TSP3519
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$; ..\TSP3519; ..\NUEDC2025
  OBJCOPY.OOCOutputFile: empty_mspm0g3519_nortos_iar.srec
  ILINK.IlinkOutputFile: empty_mspm0g3519_nortos_iar.out
  ILINK.IlinkIcfFile: mspm0g3519.icf
  ILINK.IlinkExtraOptions: $MSPM0_SDK_INSTALL_DIR$/source/ti/driverlib/lib/iar/m0p/mspm0gx51x/driverlib.a; --silent
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SysConfig_Generated_Files.ipcf
  group empty_mspm0g3519
    ./: empty_mspm0g3519.c empty_mspm0g3519.syscfg mspm0g3519.icf README.md
  group empty_mspm0g3519/iar
    iar/: startup_mspm0g351x_iar.c
  group NUEDU2025
    ../NUEDC2025/: tsp_isr.c tsp_isr.h tsp_liball.h
  group SysConfig Generated Files
    ./: Event.dot ti_msp_dl_config.c ti_msp_dl_config.h
  group TSP3519
    ../TSP3519/: tsp_common_headfile.h tsp_gpio.c tsp_gpio.h tsp_soft6050.c tsp_soft6050.h tsp_soft_i2c.c tsp_soft_i2c.h TSP_TFT18.c TSP_TFT18.h tsp_uart.h
